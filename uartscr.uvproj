# Keil uVision project uartscr.uvproj, settings and files
target uartscr (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uartscr +hex
  c flags: Optim=1
  c include: .\System\delay;.\System\sys;.\System\usart;.\HardWare;.\Ucosii\CONFIG;.\Ucosii\CORE;.\Ucosii\PORT;.\Malloc;.\UartScreen;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
  group Hardware
    ./HardWare/: key.c led.c timer.c uart2.c exit.c motor.c uart3.c steer.c
  group UartScreen
    ./UartScreen/: cmd_process.c cmd_queue.c hmi_driver.c
  group Ucosii_Core
    ./Ucosii/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ucosii_Port
    ./Ucosii/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Ucosii_Config
    ./Ucosii/CONFIG/: includes.h os_cfg.h
  group Malloc
    ./Malloc/: malloc.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Start
    ./Start/: startup_stm32f10x_hd.s
  group note
    ./User/: note.txt
